# IAR project STM8L101F3_FW_CPP.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8L10x_StdPeriph_Driver\inc; system; drivers\gpio; drivers\i2c; tests\i2c; tests\optional_bytes; utils\queue; tests\gpio; tests; utils\CmdSvr; utils\CmdSvr\I2C_CMD; drivers\SPI; drivers\interrupt; tests\Spi; utils\RTF; drivers\uart; drivers\eeprom; drivers\timers; drivers\IR; drivers\reg; drivers\watchdog
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8L101F3_FW_CPP.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group App
    app/: main.c
  group drivers/eeprom
    drivers/eeprom/: eeprom.c
  group drivers/gpio
    drivers/gpio/: DigitalIn.h DigitalOut.h
  group drivers/i2c
    drivers/i2c/: i2c.cpp
  group drivers/Interrupt
    drivers/interrupt/: interrupt.h
  group drivers/IR
    drivers/IR/: IrDecoder.h IrEncoder.h TvCodes.h
  group drivers/optional_bytes
    drivers/optional_bytes/: optional_bytes.h
  group drivers/reg
    drivers/reg/: reg_t.h
  group drivers/spi
    drivers/SPI/: Spi.cpp
  group drivers/timers
    drivers/timers/: gpt.h gpt4.h pulseIn.h pulseOut.h
  group drivers/uart
    drivers/uart/: Uart.cpp
  group drivers/watchdog
    drivers/watchdog/: IWDG.c
  group std_peripheral_lib
    STM8L10x_StdPeriph_Driver/src/: stm8l10x_clk.c stm8l10x_i2c.c stm8l10x_spi.c stm8l10x_usart.c
  group system
    system/: stm8l10x_it.c system.c
  group tests
    tests/gpio/: gpio_tests.c
    tests/i2c/: i2c_tests.cpp
    tests/Spi/: Spi_tests.cpp
    tests/: templates.h timers_test.cpp timers_test.h
    drivers/uart/: UartTest.h
  group utils/CmdSvr
    utils/CmdSvr/: CmdSvr.c
    utils/CmdSvr/I2C_CMD/: I2C_Commands.c
  group utils/queue
    utils/queue/: queue.h
  group utils/RTF
    utils/RTF/: RTF.c
