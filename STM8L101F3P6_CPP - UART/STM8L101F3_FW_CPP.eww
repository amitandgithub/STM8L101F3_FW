<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\STM8AL3168\BinProject\Flash.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\STM8L101F3_FW_CPP.ewp</path>
    </project>
    <batchBuild />
</workspace>
